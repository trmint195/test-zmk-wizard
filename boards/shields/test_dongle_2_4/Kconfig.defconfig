## boards/shields/test_dongle_2_4/Kconfig.shield
```kconfig
config SHIELD_TEST_DONGLE_2_4
    def_bool $(shields_list_contains,test_dongle_2_4)
```
